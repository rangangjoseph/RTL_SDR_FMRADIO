options:
  parameters:
    author: Joseph
    generate_options: qt_gui
    id: fmradio
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 850e5
    step: '1'
    stop: 1100e5
    value: 103304e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '75000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
